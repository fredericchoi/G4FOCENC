# Keil uVision project dgm.uvprojx, settings and files
target dgm (5060020::V5.06 (build 20)::ARMCC)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: dgm +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32G431xx,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,ARM_MATH_CM4,__TARGET_FPU_VFP
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;..\Drivers\CMSIS\DSP\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Inc/: hw_config.h
    ../Core/Src/: usr_config.c main.c systick.c led.c flash.c uart.c fdcan.c stm32g4xx_hal_fdcan.c pwm_curr_fdbk.c stm32g4xx_it.c encoder.c drv8323.c foc.c fsm.c controller.c trapTraj.c calibration.c anticogging.c heap.c util.c OLED_I2C.c stm32g4xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
    ../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM4lf_math.lib
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_ll_gpio.c stm32g4xx_ll_dma.c stm32g4xx_ll_spi.c stm32g4xx_ll_pwr.c stm32g4xx_ll_usart.c stm32g4xx_ll_rcc.c stm32g4xx_ll_tim.c stm32g4xx_ll_adc.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_i2c.c stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_gpio.c
software components: CMSIS:CORE 5.1.2
